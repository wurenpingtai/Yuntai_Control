## Kconfig
```kconfig
menuconfig MODULES_YUNTAI
	bool "yuntai"
	default n
	---help---
		Enable support for yuntai
```
